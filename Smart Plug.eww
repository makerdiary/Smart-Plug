<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\APP\Smart_Plug\Smart_Plug.ewp</path>
  </project>
  <batchBuild/>
</workspace>


