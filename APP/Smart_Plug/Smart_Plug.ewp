# IAR project Smart_Plug.ewp, settings and files
configuration Coordinator (ARM)
  General.OGChipSelectEditMenu: EM773 NXP EM773
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OS_FREE_RTOS; SMARTPLUG_COORDINATOR; IAR_BUILD_ENV; IAR_ARM_CC
  ICCARM.CCIncludePath2: ..\..\SYSTEM\EM7XX\; ..\..\CMSIS\CM0\CoreSupport\; ..\..\CMSIS\CM0\DeviceSupport\EM7XX\; ..\..\OS\; ..\..\OS\FreeRTOS\Source\include\; ..\..\OS\FreeRTOS\Source\portable\IAR\ARM_CM0\; SRC\; ..\..\LIB\; ..\COMMON\; ..\MESSAGES\; ..\..\DRIVERS\COMMON\; ..\..\DRIVERS\GPIO\; ..\..\DRIVERS\UART\; ..\..\DRIVERS\WDT\; ..\..\DRIVERS\I2C\; ..\..\DRIVERS\ZNP\; ..\..\DRIVERS\ZNP_HAL\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: IAR_BUILD_ENV
  AARM.AUserIncludes: ..\..\SYSTEM\EM7XX\; ..\..\CMSIS\CM0\CoreSupport\; ..\..\CMSIS\CM0\DeviceSupport\EM7XX\; ..\..\OS\; ..\..\OS\FreeRTOS\Source\include; ..\..\OS\FreeRTOS\Source\portable\IAR\ARM_CM0; src\; ..\..\LIB\; ..\COMMON\; ..\..\DRIVERS\COMMON\; ..\..\DRIVERS\GPIO\; ..\..\DRIVERS\UART\; ..\..\DRIVERS\WDT\
  OBJCOPY.OOCOutputFile: Smart_Plug_Coordinator.hex
  ILINK.IlinkOutputFile: Smart_Plug_Coordinator.out
  ILINK.IlinkIcfFile: EM773_Flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\LIB\dbg_metrology.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Router (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: OS_FREE_RTOS; SMARTPLUG_ROUTER; IAR_BUILD_ENV; IAR_ARM_CC
configuration EndDevice (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: OS_FREE_RTOS; SMARTPLUG_ENDDEVICE; IAR_BUILD_ENV; IAR_ARM_CC
  group CMSIS
    ../../CMSIS/CM0/CoreSupport/: core_cm0.c core_cm0.h
    ../../CMSIS/CM0/DeviceSupport/EM7XX/: system_EM7xx.c system_EM7xx.h
  group COMMON
    ../COMMON/: string_functions.c string_functions.h
  group DRIVERS
    ../../DRIVERS/COMMON/: conversions.c conversions.h
    ../../DRIVERS/GPIO/: gpio.c gpio.h pcb.c pcb.h
    ../../DRIVERS/I2C/: i2c.c i2c.h
    ../../DRIVERS/UART/: uart.c uart.h
    ../../DRIVERS/WDT/: wdt.c wdt.h
    ../../DRIVERS/ZNP_HAL/: znp_hal.c znp_hal.h
  group DRIVERS/ZNP
    ../../DRIVERS/ZNP/: af_zdo.c af_zdo.h application_configuration.c application_configuration.h mainpage.h simple_api.c simple_api.h znp_commands.c znp_commands.h znp_interface.c znp_interface.h znp_interface_spi.c znp_interface_spi.h znp_util_interface.c znp_util_interface.h znpRfTestInterface.c znpRfTestInterface.h
  group FreeRTOS
    ../../OS/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c
    ../../OS/FreeRTOS/Source/include/: croutine.h FreeRTOS.h list.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
    ../../OS/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../OS/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group Messages
    ../Messages/: header.c header.h infoMessage.c infoMessage.h
  group RTK
    ../../OS/: rtk.h rtk_FreeRTOS.c
  group src
    src/: app.c app.h app_config.h bsp.c bsp.h dprint_macros.h FreeRTOSConfig.h lcd.c lcd.h main.c main.h nvmem.c nvmem.h rf_cfg.h rfhandler.c rfhandler.h startup_armcm0.s
    ../../LIB/: metrology.h
